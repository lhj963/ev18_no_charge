# Keil uVision project KeilMDK.uvproj, settings and files
target Application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: KeilMDK +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\Source\main;..\Source\apps;..\Source\sysapi
  library: MicroLIB
  scatter file: .\output\KeilMDK.sct
  group main
    ../Source/main/: main.c
  group apps
    ../Source/apps/: apps.c
  group startup
    ../Source/startup/: startup.s
  group sysapi
    ../Source/sysapi/: sysapi.c
